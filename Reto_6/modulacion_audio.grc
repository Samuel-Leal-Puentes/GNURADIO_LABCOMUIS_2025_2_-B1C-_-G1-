options:
  parameters:
    generate_options: qt_gui
    id: modulacion_audio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 25e6/64
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    alias: Piloto
    amp: '1'
    freq: '19000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '38000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    fh: '-1.0'
    max_dev: 75e3
    tau: '75e-6'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/estudiante/Documentos/B1C/Ret_6/stereo-test.mp3
    nchan: '2'
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: L+R
    label2: L-R
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"green"'
    color2: '"magenta"'
    fc: '0'
    fftsize: '1024'
    label1: (L-R)*cos(38K)
    label2: Piloto
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"black"'
    fc: '0'
    fftsize: '1024'
    label1: Modulacion
    type: float
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '32000'
    interp: int(samp_rate)
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '32000'
    interp: int(samp_rate)
    type: fff
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_1, '2']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_add_xx_1, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_1, '0', analog_wfm_tx_0, '0']
- [blocks_add_xx_1, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_1, '1']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_sub_xx_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_wavfile_source_0, '1', rational_resampler_xxx_0_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_add_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_sub_xx_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_add_xx_0, '1']
- [rational_resampler_xxx_0_0_0, '0', blocks_sub_xx_0, '1']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
